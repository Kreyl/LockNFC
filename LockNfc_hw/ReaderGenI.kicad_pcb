# Repository Kreyl/LockNFC

## KiCad design LockNfc_hw/ReaderGenI.kicad_pcb

Parts:
C1, C2: 10n; CAP_0603
C3, C5, C13, C33, C38: 1n; CAP_0603
C4, C6, C7, C8, C10, C29, C31, C32, C34, C36, C37: 0.1u; CAP_0603
C9, C14: 1u; CAP_0603
C11, C16, C22: 4.7u; CAP_0603
C12, C15: 18p; CAP_0603
C17, C18: 22p; CAP_0603
C19, C20: 220p; CAP_0603
C21, C24: 12p; CAP_0603
C23: 10u; CAP_0805
C27, C28: 132p; CAP_0603
C30, C35: 4u7; CAP_0603
D1, D2, D3, D4, D5, D6: LED
DA1: TLV700XX
DD1: STM32L151-48
DD2: PN532
L1, L3: BLM21PG221SN1; IND_0805
L2: DLP11SN900HL2L
L4, L5: 560n; IND_0603
PN_IRQ1: MOSI
PN_MISO1: MISO
PN_MOSI1: MOSI
PN_NSS1: NSS
PN_SCK1: SCK
R1: 1M; RES_0603
R2, R3, R6, R7, R8, R9, R13: 1k; RES_0603
R4: 510R; RES_0603
R10, R12: 1; RES_0603
R11: 0; RES_0603
R14: 2k7; RES_0603
RP1, RP2, RP3, RP4: REFPOINT
U1: USBLC6_2XX
XL1: CONN_2
XL2: ST_SWD
XL3: USB_MINI_B
XTAL1: 8MHz; CRYSTAL
XTAL2: 27.12MHz; CRYSTAL

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C13.1, C14.1, C16.1, C22.1, C36.1, DA1.5, DD1.1, DD1.9, DD1.24, DD1.36, DD1.48, DD2.23 (PVDD), XL2.1 (Vdd)
+5V: C10.1, C11.1, C23.1, C37.1, DA1.1, DA1.3, DD2.40 (VBAT), L1.1, U1.5 (VBus)
/ANT01: DD2.4 (TX1), L4.2
/ANT02: DD2.6 (TX2), L5.1
/Antenna: R10.2, R11.2, R12.2
/BLUE_LED: DD1.12, R6.1, R7.1
/DBG_UART_TX: DD1.30, XL1.1
/ORANGE_LED: DD1.13, R8.1, R9.1
/PN_IRQ: DD1.19, DD2.25 (P70_IRQ), PN_IRQ1.1
/PN_MISO: DD1.16, DD2.29 (MISO\P71), PN_MISO1.1
/PN_MOSI: DD1.17, DD2.28 (MOSI\SDA\HSU_TX), PN_MOSI1.1
/PN_NSS: DD1.18, DD2.27 (NSS\P50_SCL\HSU_RX), PN_NSS1.1
/PN_RESET: DD1.14, DD2.38 (RSTPD_N)
/PN_SCK: DD1.15, DD2.30 (SCK\P72), PN_SCK1.1
/PN_VDD: C29.1, C30.1, C32.1, C34.1, C35.1, C38.1, DD2.5 (TVDD), DD2.8 (AVDD), DD2.17 (I1), DD2.39 (DVDD)
/RED_LED: DD1.11, R2.1, R3.1
/RX_NET: C20.2, C24.2, L5.2, R14.2
/SWCLK: DD1.37, XL2.2 (SWCLK)
/SWDIO: DD1.34, XL2.4 (SWDIO)
/USB_DM: DD1.32, U1.6 (I/O1)
/USB_DP: DD1.33, U1.4 (I/O2)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C22.2, C23.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C38.2, D1.C, D2.C, D3.C, D4.C, D5.C, D6.C, DA1.2, DD1.8, DD1.23, DD1.35, DD1.44, DD1.47, DD1.PAD, DD2.1 (DVSS), DD2.3 (TVSS1), DD2.7 (TVSS2), DD2.11 (AVSS), DD2.16 (I0), DD2.18 (TESTEN), DD2.PAD, L3.1, R1.1, R11.1, U1.2 (GND), XL1.2 (PM), XL2.3 (GND), XTAL1.H, XTAL2.H
unnamed: C31.1, DD2.9 (VMID), R13.2
unnamed: C17.1, DD2.14 (OSCIN), XTAL2.1
unnamed: C18.1, DD2.15 (OSCOUT), XTAL2.2
unnamed: C24.1, C28.2, R12.1
unnamed: C21.1, C27.1, R10.1
unnamed: C33.2, R14.1
unnamed: L2.1, XL3.2 (D-)
unnamed: L2.4, XL3.3 (D+)
unnamed: L2.2, U1.1 (I/O1)
unnamed: C12.1, R4.2, XTAL1.1
unnamed: C15.1, DD1.5, XTAL1.2
unnamed: DD1.6, R4.1
unnamed: C33.1, DD2.10 (RX), R13.1
unnamed: C19.1, C21.2, L4.1
unnamed: L2.3, U1.3 (I/O2)
unnamed: L3.2, XL3.4 (UGND), XL3.5 (UID)
unnamed: C2.2, L1.2, XL3.1 (UVcc)
unnamed: C1.2, R1.2, XL3.SHLD
unnamed: D4.A, R7.2
unnamed: D6.A, R9.2
unnamed: D5.A, R8.2
unnamed: D3.A, R6.2
unnamed: D2.A, R3.2
unnamed: D1.A, R2.2

Notes on the sheet:
Debug port & stuff
Programming
USB
CPU
Indication
Antenna
Power
WWPASS Reader G.II
Orange Led
Blue Led
Red Led
Damping Resistors
Matching Circuit
EMC Filter
SPI Mode
DLP11SN900HL2L or DLW21SN900SQ2L or two BLM18BB121SN1D
Low-capacitance ESD protection

Board: 2 copper layers, 115.2 x 84.0 mm, 79 parts (36 on the bottom side), 46 nets.

Other parts of the board:
NAME: VALUE; LOGO
