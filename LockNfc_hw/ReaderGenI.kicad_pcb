# Repository Kreyl/LockNFC (continued)

## KiCad design LockNfc_hw/LockNfc3.kicad_pcb

Parts:
C1, C3: 10n
C2, C7, C9, C10, C12, C13, C17, C18, C23, C24, C25, C27, C28, C29, C39, C40, C41, C42, C44, C46, C48: 0.1u; CAP_0603
C4, C5: 22p; CAP_0603
C6, C15, C35, C38, C45, C47, C49: 1u; CAP_0603
C8, C14: 4u7; CAP_0603
C11, C16: 1n; CAP_0603
C19, C26, C30, C43: 10u; CAP_0805
C20, C21: 220p; CAP_0603
C22, C31: 18pF; CAP_0603
C32, C33: 100p+33p; CAP_0603
C36, C37: 20pF; CAP_0603
D1, D2: D_SHOTTKY
DA1: VS1011
DA2: TPA6211
DA3: NCP583SQ
DD1: PN532
DD2: M24C04
DD3: STM32F205RX-64
F1, F2: FUSE0R
HOLE1, HOLE2, HOLE3, HOLE4: HOLE_METALLED
L1, L2: 560n; IND_0603
Q1: IRLML9303
Q2: BC817
Q3, Q4, Q5: IRLML6302
Q6, Q7, Q8: LED_RGB
R1, R2: 4K7; RES_0603
R3, R5: 20
R4, R9, R13: 1k; RES_0603
R6: 150; RES_0603
R7, R8: 10k
R10: 220R; RES_0603
R11, R12, R18, R20, R21, R22, R23, R24, R26: 100R; RES_0603
R14: 2k7; RES_0603
R15, R16: 100k; RES_0603
R17, R19: 1; RES_0603
SW1: SS9
SW2, SW3, SW4: BUTTON
VCap1, VCap2: 2.2u; CAP_0603
XL1: CONN_4
XL2, XL3, XL11, XL12, XL13: CONN_4
XL4: ST_SWD
XL5: USB_MICRO_B
XL6: CONN_2
XL7: CONN_3
XL8: CONN_MICROSD
XL9, XL10: CONN_1
XTAL1: 27.12MHz; CRYSTAL
XTAL2: 12.0MHz; 0532

Connections:
+3.3V: C15.1, C17.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C48.1, DA1.6 (DVDD0), DA1.14 (DVDD1), DA1.19 (DVDD2), DA1.32 (TEST), DA1.38 (AVDD0), DA1.43 (AVDD1), DA1.45 (AVDD2), DA3.3 (Vout), DD1.23 (PVDD), DD2.1 (A0), DD2.2 (A1), DD2.3 (A2), DD2.8 (Vcc), DD3.1 (VBAT), DD3.13 (VDDA), DD3.19 (VDD4), DD3.32 (VDD1), DD3.48 (VDD2), DD3.64 (VDD3), Q1.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), XL4.1 (Vdd)
+5V: D1.A, F1.2, R9.2, XL5.1 (UVcc)
+BATT: C6.1, C18.1, C19.1, C49.1, D1.C, D2.C, DA2.6 (VCC), DA3.1 (EN), DA3.4 (Vin), DD1.40 (VBAT), F1.1, F2.2, R15.2
/12MHz_Clk: DA1.18 (XTALI), DD3.41 (MCO1/SCL3/T1C1/CK1/PA8)
/AMPLF_SHDN: DA2.1 (~SHDN), DD3.50 (PA15)
/ANT01: DD1.4 (TX1), L1.2
/ANT02: DD1.6 (TX2), L2.1
/Antenna: R17.2, R19.2
/BATTERY_PLUS: SW1.3, XL9.1
/BAT_MEASURE: DD3.9 ((ADC123-11)/PC1), R4.1
/BLUE_D1: Q6.BA, R22.2, XL3.3, XL12.3
/BLUE_D2: Q7.BA, R24.2, XL11.3, XL13.3
/BLUE_P: Q5.3 (D), R22.1, R24.1
/Button1: DD3.10 ((ADC123-12)/MISO2/PC2), SW2.2
/Button2: DD3.11 ((ADC123-13)/MOSI2/PC3), SW3.2
/Button3: DD3.2 (PC13), SW4.2
/GREEN_D1: Q6.GA, R21.2, XL3.2 (PM), XL12.2 (PM)
/GREEN_D2: Q7.GA, R23.2, XL11.2 (PM), XL13.2 (PM)
/GREEN_P: Q4.3 (D), R21.1, R23.1
/LED_B: DD3.57 (PB5/MOSI3/T3C2/MOSI1), Q5.1 (G)
/LED_G: DD3.27 (PB1/T3C4/(ADC12-9)), Q4.1 (G)
/LED_R: DD3.26 (PB0/T3C3/(ADC12-8)), Q3.1 (G)
/PN_IRQ: DD1.25 (P70_IRQ), DD3.15 ((ADC123-1)/RX4/T5C2/T2C2/PA1)
/PN_MISO: DD1.29 (MISO\P71), DD3.22 ((ADC12-6)/T13C1/T3C1/MISO1/PA6)
/PN_MOSI: DD1.28 (MOSI\SDA\HSU_TX), DD3.23 ((ADC12-7)/T14C1/T3C2/MOSI1/PA7)
/PN_NSS: DD1.27 (NSS\P50_SCL\HSU_RX), DD3.14 ((ADC123-0)/TX4/T5C1/WKUP/PA0)
/PN_RESET: DD1.38 (RSTPD_N), DD3.20 ((ADC12-4)/(DAC1)/CK2/PA4)
/PN_SCK: DD1.30 (SCK\P72), DD3.21 ((ADC12-5)/(DAC2)/SCK1/PA5)
/PN_VDD: C7.1, C8.1, C10.1, C12.1, C14.1, C16.1, DD1.5 (TVDD), DD1.8 (AVDD), DD1.17 (I1), DD1.39 (DVDD)
/P_SCL: DD2.6 (SCL), DD3.58 (PB6/SCL1/T4C1/TX1), R1.1, XL1.2 (PM)
/P_SDA: DD2.5 (SDA), DD3.59 (PB7/SDA1/T4C2/RX1), R2.1, XL1.4
/PeriphPwr: DD3.62 (PB9/SDIO_D5/T4C4/T11C1/SDA1), R1.2, R2.2, R6.2
/PeriphPwr1: R6.1, XL1.1
/RED_D1: Q6.RA, R20.2, XL3.1, XL12.1
/RED_D2: Q7.RA, R18.2, XL11.1, XL13.1
/RED_P: Q3.3 (D), R18.1, R20.1
/RX2: DD3.17 ((ADC123-3)/T5C4/T9C2/T2C4/RX2/PA3), XL7.3
/RX_NET: C21.2, C31.2, L2.2, R14.2
/SD_CLK: DD3.53 (MOSI3/TX5/CK3/SDIO_CK/PC12), XL8.5 (SCK/CLK)
/SD_CMD: DD3.54 (PD2/SDIO_CMD/RX5), XL8.3 (MOSI/CMD)
/SD_DAT0: DD3.39 (T8C3/T3C3/CK6/SDIO_D0/PC8), XL8.7 (MISO/DAT0)
/SD_DAT1: DD3.40 (MCO2/T8C4/SDA3/T3C4/SDIO_D1/PC9), XL8.8 (DAT1)
/SD_DAT2: DD3.51 (SCK3/TX4/TX3/SDIO_D2/PC10), XL8.1 (DAT2)
/SD_DAT3: DD3.52 (MISO3/RX4/RX3/SDIO_D3/PC11), XL8.2 (~SS~/DAT3)
/SD_POWER: DD3.24 ((ADC12-14)/PC4), Q1.1 (G)
/SD_VDD: C2.1, Q1.3 (D), XL8.4 (VDD)
/SND_L: C38.1, DA1.46 (LEFT), R5.2
/SND_R: C35.1, DA1.39 (RIGHT), R3.2
/SWCLK: DD3.49 (SWCLK/(PA14)), XL4.2 (SWCLK)
/SWDIO: DD3.46 (SWDIO/(PA13)), XL4.4 (SWDIO)
/TX2: DD3.16 ((ADC123-2)/T5C3/T9C1/T2C3/TX2/PA2), XL7.2 (PM)
/UBat_2: DD3.8 ((ADC123-10)/PC0), R15.1, R16.2
/USB_DM: DD3.44 (OTGFS_DM/T1C4/PA11), XL5.2 (D-)
/USB_DP: DD3.45 (OTGFS_DP/PA12), XL5.3 (D+)
/VS_DREQ: DA1.8 (DREQ), DD3.28 (PB2/BOOT1)
/VS_RST: DA1.3 (~xRESET), DD3.56 (PB4/MISO3/T3C1/MISO1)
/VS_SCLK: DA1.28 (SCLK), DD3.34 (PB13/SCK2)
/VS_SI: DA1.29 (SI), DD3.36 (PB15/MOSI2/T12C2)
/VS_SO: DA1.30 (SO), DD3.35 (PB14/MISO2/T12C1)
/VS_XCS: DA1.23 (~xCS), DD3.55 (PB3/SCK3/T2C2/SCK1)
/VS_XDCS: DA1.13 (~xDCS~/BSYNC), DD3.61 (PB8/SDIO_D4/T4C3/T10C1/SCL1)
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C32.2, C33.1, C36.2, C37.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.1, C48.2, C49.2, DA1.4 (DGND0), DA1.16 (DGND1), DA1.20 (DGND2), DA1.21 (DGND3), DA1.22 (DGND4), DA1.37 (AGND0), DA1.40 (AGND1), DA1.41 (AGND2), DA1.47 (AGND3), DA2.7 (GND), DA2.PAD, DA3.2 (GND), DD1.1 (DVSS), DD1.3 (TVSS1), DD1.7 (TVSS2), DD1.11 (AVSS), DD1.16 (I0), DD1.18 (TESTEN), DD1.PAD, DD2.4 (GND), DD2.7 (WP), DD3.12 (VSSA), DD3.18 (VSS4), DD3.60 (BOOT0), DD3.63 (VSS3), HOLE1.Hle, HOLE2.Hle, HOLE3.Hle, HOLE4.Hle, Q2.2 (E), Q6.BC (B), Q6.GC (G), Q6.RC, Q7.BC (B), Q7.GC (G), Q7.RC, Q8.BC (B)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
unnamed: C9.1, DD1.9 (VMID), R13.2
unnamed: C5.1, DD1.15 (OSCOUT), XTAL1.2
unnamed: C4.1, DD1.14 (OSCIN), XTAL1.1
unnamed: C22.1, C32.1, R17.1
unnamed: C11.2, R14.1
unnamed: C20.1, C22.2, L1.1
unnamed: C11.1, DD1.10 (RX), R13.1
unnamed: C31.1, C33.2, R19.1
unnamed: D2.A, F2.1, SW1.2
unnamed: Q8.BA, R26.2
unnamed: Q8.GA, R12.2
unnamed: Q8.RA, R11.2
unnamed: DD3.30 (PB11/SDA2/RX3/T2C4), R12.1
unnamed: DD3.33 (PB12/CK3), R26.1
unnamed: DD3.29 (PB10/SCK2/SCL2/TX3/T2C3), R11.1
unnamed: DD3.38 (T8C2/RX6/T3C2/SDIO_D7/PC7), XL2.3
unnamed: DD3.37 (T8C1/TX6/T3C1/SDIO_D6/PC6), XL2.2 (PM)
unnamed: DD3.25 ((ADC12-15)/PC5), XL2.1
unnamed: C47.2, DA2.2 (Cbp)
unnamed: DA2.5 (OUT+), XL6.1
unnamed: DD3.47 (VCap2), VCap2.1
unnamed: DD3.6 (PH1/OSCOUT), R10.1
unnamed: DA2.4 (IN-), R7.2
unnamed: C38.2, R7.1
unnamed: DA2.3 (IN+), R8.2
unnamed: C35.2, R8.1
unnamed: DA2.8 (OUT-), XL6.2 (PM)
unnamed: DD3.42 ((OTGFS_VBUS)/T1C2/TX1/PA9), R9.1
unnamed: DD3.31 (VCap1), VCap1.1
unnamed: C13.1, DA1.44 (RCAP)
unnamed: C1.2, R3.1
unnamed: C37.1, R10.2, XTAL2.2
unnamed: C36.1, DD3.5 (PH0/OSCIN), XTAL2.1
unnamed: C3.2, R5.1
unnamed: Q2.1 (B), R4.2
unnamed: Q2.3 (C), R16.1

Notes on the sheet:
USB connect detector
USB
CPU
Programming
Audio
SD card
Battery meter
Power
Amplifier
DEBUG TX/RX
Hi-power mono
3.3V 150mA power regulator
Remove diodes and solder fuse if some power source is not used
Antenna
Damping Resistors
Matching Circuit
EMC Filter
SPI Mode
Peripheral I2C Pull-Ups
Pill Connector
Pill
I2C Addr = 1010 111
Keys storage
Just pins
Buttons

Board: 2 copper layers, 109.0 x 64.0 mm, 118 parts (7 on the bottom side), 98 nets.

## Code that names these connections

File LockNFC_fw/sound.h:

/*
 * File:   media.h
 * Author: g.kruglov
 *
 * Created on June 15, 2011, 4:44 PM
 */

#ifndef MEDIA_H
#define	MEDIA_H

#include "kl_sd.h"
#include <stdint.h>
#include "kl_lib_f2xx.h"
#include "cmd_uart.h"

// ==== Defines ====
#define VS_GPIO         GPIOB
// Pins
#define VS_XCS          3
#define VS_XDCS         8
#define VS_RST          4
#define VS_DREQ         2
#define VS_XCLK         13
#define VS_SO           14
#define VS_SI           15
// Amplifier
#define VS_AMPF_EXISTS  TRUE
#define VS_AMPF_GPIO    GPIOA
#define VS_AMPF_PIN     15

// SPI
#define VS_SPI          SPI2
#define VS_AF           AF5
#define VS_SPI_RCC_EN() rccEnableSPI2(FALSE)
// DMA
#define VS_DMA          STM32_DMA1_STREAM4
#define VS_DMA_CHNL     0
#define VS_DMA_MODE     STM32_DMA_CR_CHSEL(VS_DMA_CHNL) | \
                        DMA_PRIORITY_LOW | \
                        STM32_DMA_CR_MSIZE_BYTE | \
                        STM32_DMA_CR_PSIZE_BYTE | \
                        STM32_DMA_CR_DIR_M2P |    /* Direction is memory to peripheral */ \
                        STM32_DMA_CR_TCIE         /* Enable Transmission Complete IRQ */

// Command codes
#define VS_READ_OPCODE  0b00000011
#define VS_WRITE_OPCODE 0b00000010

// Registers
#define VS_REG_MODE         0x00
#define VS_REG_STATUS       0x01
#define VS_REG_BASS         0x02
#define VS_REG_CLOCKF       0x03
#define VS_REG_DECODE_TIME  0x04
#define VS_REG_AUDATA       0x05
#define VS_REG_WRAM         0x06
#define VS_REG_WRAMADDR     0x07
#define VS_REG_HDAT0        0x08
#define VS_REG_HDAT1        0x09
#define VS_REG_AIADDR       0x0A
#define VS_REG_VOL          0x0B

enum sndState_t {sndStopped, sndPlaying, sndWritingZeroes};

union VsCmd_t {
    struct {
        uint8_t OpCode;
        uint8_t Address;
        uint16_t Data;
    } PACKED;
    msg_t Msg;
};

#define VS_VOLUME_STEP          4
#define VS_INITIAL_ATTENUATION  0x33
#define VS_CMD_BUF_SZ           4       // Number of cmds in buf
#define VS_DATA_BUF_SZ          4096    // bytes. Must be multiply of 512.
#define ZERO_SEQ_LEN            128     // After file end, send several zeroes

struct VsBuf_t {
    uint8_t Data[VS_DATA_BUF_SZ], *PData;
    UINT DataSz;
    FRESULT ReadFromFile(FIL *PFile) {
        PData = Data;   // Set pointer at beginning
        FRESULT rslt = f_read(PFile, Data, VS_DATA_BUF_SZ, &DataSz);
//        Uart.Printf("\rRead %u\r", DataSz);
        return rslt;
    }
};

// Event mask to wake from IRQ
#define VS_EVT_READ_NEXT    (eventmask_t)1
#define VS_EVT_STOP         (eventmask_t)2
#define VS_EVT_COMPLETED    (eventmask_t)4
#define VS_EVT_DMA_DONE     (eventmask_t)8
#define VS_EVT_DREQ_IRQ     (eventmask_t)16

class Sound_t {
private:
    Spi_t ISpi;
    msg_t CmdBuf[VS_CMD_BUF_SZ];
    Mailbox CmdBox;
    VsCmd_t ICmd;
    VsBuf_t Buf1, Buf2, *PBuf;
    uint32_t ZeroesCount;
    FIL IFile;
    bool IDmaIdle;
    int16_t IAttenuation;
    const char* IFilename;
    uint32_t IStartPosition;
    Thread *IPAppThd;
    // Pin operations
    inline void Rst_Lo()   { PinClear(VS_GPIO, VS_RST); }
    inline void Rst_Hi()   { PinSet(VS_GPIO, VS_RST); }
    inline void XCS_Lo()   { PinClear(VS_GPIO, VS_XCS); Loop(180); }
    inline void XCS_Hi()   { PinSet(VS_GPIO, VS_XCS);  }
    inline void XDCS_Lo()  { PinClear(VS_GPIO, VS_XDCS); Loop(360); }
    inline void XDCS_Hi()  { PinSet(VS_GPIO, VS_XDCS); }
    // Cmds
    uint8_t CmdRead(uint8_t AAddr, uint16_t *AData);
    uint8_t CmdWrite(uint8_t AAddr, uint16_t AData);
    void AddCmd(uint8_t AAddr, uint16_t AData);
    inline void StartTransmissionIfNotBusy() {
        chSysLock();
        if(IDmaIdle and IDreq.IsHi()) {
//            Uart.PrintfI("\rTXinB");
            IDreq.EnableIrqI(IRQ_PRIO_MEDIUM);
            IDreq.GenerateIrq();    // Do not call SendNexData directly because of its interrupt context
        }
        chSysUnlock();
    }
    void PrepareToStop();
    void SendZeroes();
    void IPlayNew();
public:
    sndState_t State;
    void Init();
    void Shutdown();
    void Play(const char* AFilename, uint32_t StartPosition = 0) {
        IFilename = AFilename;
        if(StartPosition & 1) StartPosition--;
        IStartPosition = StartPosition;
        chEvtSignal(PThread, VS_EVT_STOP);
    }
    void Stop() {
        IFilename = NULL;
        chEvtSignal(PThread, VS_EVT_STOP);
    }
    // 0...254
    void SetVolume(uint8_t AVolume) {
        if(AVolume == 0xFF) AVolume = 0xFE;
        IAttenuation = 0xFE - AVolume; // Transform Volume to attenuation
        AddCmd(VS_REG_VOL, ((IAttenuation * 256) + IAttenuation));
    }
    void VolumeIncrease() {
        IAttenuation -= VS_VOLUME_STEP;
        if(IAttenuation < 0) IAttenuation = 0;
        AddCmd(VS_REG_VOL, ((IAttenuation * 256) + IAttenuation));
    }
    void VolumeDecrease() {
        IAttenuation += VS_VOLUME_STEP;
        if(IAttenuation > 0x8F) IAttenuation = 0x8F;
        AddCmd(VS_REG_VOL, ((IAttenuation * 256) + IAttenuation));
    }
    void RegisterAppThd(Thread *PThd) { IPAppThd = PThd; }

    uint32_t GetPosition() { return IFile.fptr; }
#if VS_AMPF_EXISTS
    void AmpfOn()  { PinSet(VS_AMPF_GPIO, VS_AMPF_PIN); }
    void AmpfOff() { PinClear(VS_AMPF_GPIO, VS_AMPF_PIN); }
#endif
    // Inner use
    IrqPin_t IDreq;
    Thread *PThread;
    void IrqDreqHandler();
    void ITask();
    void ISendNextData();
};

extern Sound_t Sound;

//#endif  // Sound Enabled

#endif	/* MEDIA_H */

File LockNFC_fw/pn.h:

/*
 * pn.h
 *
 *  Created on: 09 ÿíâ. 2015 ã.
 *      Author: Kreyl
 */

#ifndef PN_H_
#define PN_H_

#include "ch.h"
#include "kl_lib_f2xx.h"
#include "pn_defins.h"

#if 1 // ===================== GPIO, DMA etc. ==================================
// SPI clock is up to 5MHz (um p.45)
#define PN_SPI      SPI1

// ==== DMA ====
#define PN_TX_DMA           STM32_DMA2_STREAM5
#define PN_TX_DMA_CHNL      3
#define PN_TX_DMA_MODE \
    STM32_DMA_CR_CHSEL(PN_TX_DMA_CHNL) |               \
    DMA_PRIORITY_MEDIUM |                              \
    STM32_DMA_CR_MSIZE_BYTE | /* Size byte */          \
    STM32_DMA_CR_PSIZE_BYTE |                          \
    STM32_DMA_CR_MINC |       /* Mem pointer increase */  \
    STM32_DMA_CR_DIR_M2P |    /* Mem to peripheral */  \
    STM32_DMA_CR_TCIE

#define PN_RX_DMA           STM32_DMA2_STREAM2
#define PN_RX_DMA_CHNL      3
#define PN_RX_DMA_MODE      STM32_DMA_CR_CHSEL(PN_RX_DMA_CHNL) |               \
                            DMA_PRIORITY_HIGH |                                \
                            STM32_DMA_CR_MSIZE_BYTE | /* Memory Size - Byte */ \
                            STM32_DMA_CR_PSIZE_BYTE | /* Periph Size - Byte */ \
                            STM32_DMA_CR_MINC |    /* Mem pointer increase */  \
                            STM32_DMA_CR_DIR_P2M | /* Periph to Mem */         \
                            STM32_DMA_CR_TCIE      /* Enable Transmission Int C */

// ==== PN532 GPIOs PINs ====
#define PN_GPIO             GPIOA
#define PN_IRQ_GPIO         GPIOA
#define PN_NSS_GPIO         GPIOA
#define PN_IRQ_PIN          1
#define PN_NSS_PIN          0
#define PN_SCK_PIN          5
#define PN_MISO_PIN         6
#define PN_MOSI_PIN         7
#define PN_RST_PIN          4

#if PN_IRQ_PIN == 0
#define PN_IRQ_HANDLER    EXTI0_IRQHandler
#elif PN_IRQ_PIN == 1
#define PN_IRQ_HANDLER    EXTI1_IRQHandler
#elif PN_IRQ_PIN == 2
#define PN_IRQ_HANDLER    EXTI2_IRQHandler
#elif PN_IRQ_PIN == 3
#define PN_IRQ_HANDLER    EXTI3_IRQHandler
#elif PN_IRQ_PIN == 4
#define PN_IRQ_HANDLER    EXTI4_IRQHandler
#endif

#endif

// Buf sizes
#define PN_MAX_DATA_SZ      265  // Max Data Lenghth=265 including TFI um. page 29

// Timings
#define PN_ACK_TIMEOUT      27  // ms
#define PN_DATA_TIMEOUT     180 // ms
#define PN_POLL_INTERVAL    504 // ms

#if 1 // ======================= Auxilary structures ===========================
struct PnPrologue_t {
    uint8_t Preamble;       // Always 0x00
    uint8_t SoP0;           // Start of Packet Code 0
    uint8_t SoP1;           // Start of Packet Code 1
    uint8_t Len;            // Length
    uint8_t LCS;            // Length Checksum
    bool IsStartOk()  { return (Preamble == 0 and SoP0 == 0 and SoP1 == 0xFF); }
    bool IsExtended() { return (Len == 0xFF and LCS == 0xFF); }
    bool IsLcsOk()    { return ((uint8_t)(Len + LCS) == 0); }
} __attribute__ ((__packed__));
#define PROLOGUE_SZ  sizeof(PnPrologue_t)

struct PnPrologueExt_t {
    uint8_t Preamble;       // Always 0x00
    uint8_t SoP0;           // Start of Packet Code 0
    uint8_t SoP1;           // Start of Packet Code 1
    uint8_t NPLC;           // Normal Packet Length - 0xFF always for extended frame
    uint8_t NPL;            // Normal Packet Length Checksum - 0xFF always for extended frame
    uint8_t LengthHi;       // MSByte of Length
    uint8_t LengthLo;       // LSByte of Length
    uint8_t LCS;            // Length Checksum
    void CalcLCS() { LCS = -(LengthHi + LengthLo); }
    bool IsLcsOk()    { return ((uint8_t)(LengthHi + LengthLo + LCS) == 0); }
} __attribute__ ((__packed__));
#define PROLOGUE_EXT_SZ  sizeof(PnPrologueExt_t)

struct PnEpilogue_t {
    uint8_t DCS;
    uint8_t Postamble;
} __attribute__ ((__packed__));
#define EPILOGUE_SZ  sizeof(PnEpilogue_t)

struct PnAckNack_t {
    uint8_t Preamble;
    uint8_t SoP0;           // Start of Packet Code 0
    uint8_t SoP1;           // Start of Packet Code 1
    uint8_t Code0;
    uint8_t Code1;
    uint8_t Postamble;
    bool operator == (const PnAckNack_t &APkt) { return (Preamble == APkt.Preamble) and (SoP0 == APkt.SoP0) and (SoP1 == APkt.SoP1) and (Code0 == APkt.Code0) and (Code1 == APkt.Code1) and (Postamble == APkt.Postamble); }
} __attribute__ ((__packed__));
#define PN_ACK_NACK_SZ sizeof(PnAckNack_t)

const PnAckNack_t PnPktAck = {0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00};

// Auxilary Data indxs, sizes etc
#define PN_PROLOGUE_INDX    1
#define PN_DATA_EXT_INDX    (1 + PROLOGUE_EXT_SZ)   // index in buffer
#define PN_DATA_NORMAL_INDX (1 + PROLOGUE_SZ)       // index in buffer
#define PN_TX_SZ(ALength)   (1 + PROLOGUE_EXT_SZ + ALength + EPILOGUE_SZ)

struct PnReply_t {
    uint8_t TFI;
    struct {
        uint8_t RplCode;
        union {
            uint8_t NbTg;
            uint8_t Err;
            uint8_t Slot;
        };
        uint8_t Buf[PN_MAX_DATA_SZ-3]; // exclude TFI, RplCode and ErrCode
    } __attribute__ ((__packed__));
} __attribute__ ((__packed__));

#endif

#if 1 // =========================== PN class ==================================
enum PnState_t {psOff, psSetup, psConfigured};

class PN532_t {
private:
    PnState_t State;
    IrqPin_t IIrqPin;
    // Frame
    uint8_t IBuf[1 + PROLOGUE_EXT_SZ + PN_MAX_DATA_SZ + EPILOGUE_SZ]; // Seq type + prologue +...
    PnPrologue_t    *Prologue    = (PnPrologue_t*)   &IBuf[PN_PROLOGUE_INDX];  // Exclude Seq type
    PnPrologueExt_t *PrologueExt = (PnPrologueExt_t*)&IBuf[PN_PROLOGUE_INDX];  // Exclude Seq type
    PnReply_t *PReply;
    uint32_t RxDataSz;
    void WriteEpilogue(uint16_t ALength) { // [TFI + PD0 + PD1 +  + PDn + DCS] = 0x00
        uint8_t *p = &IBuf[PN_DATA_EXT_INDX]; // Beginning of TFI+Data
        uint8_t Dcs = 0;
        for(uint16_t i=0; i<ALength; i++) Dcs += *p++;
        Dcs = - Dcs;
        *p++ = Dcs; // DCS
        *p = 0x00;  // Postamble
    }
    bool CardOk = false;
    // Gpio
    inline void IRstLo()  { PinClear(PN_GPIO, PN_RST_PIN); }
    inline void IRstHi()  { PinSet  (PN_GPIO, PN_RST_PIN); }
    inline void INssLo()  {
        PinClear(PN_NSS_GPIO, PN_NSS_PIN);
        Loop(200);
        // chThdSleepMicroseconds(20);
    }
    inline void INssHi()  { PinSet  (PN_NSS_GPIO, PN_NSS_PIN); }
    // Inner use
    void IReset();
    // ==== Data Exchange ====
    uint8_t Cmd(uint8_t CmdID, uint32_t ADataLength, ...);
    uint8_t ReceiveAck();
    uint8_t ReceiveData();
    void ITxRx(void *PTx, void *PRx, uint32_t ALength);
    uint8_t WaitReplyReady(uint32_t ATimeout);
    // ==== Hi lvl ====
    bool CardAppeared();
    bool CardIsStillNear();
    void FieldOn()  { Cmd(PN_CMD_RF_CONFIGURATION, 2, 0x01, 0x01); }
    void FieldOff() { Cmd(PN_CMD_RF_CONFIGURATION, 2, 0x01, 0x00); }
    uint8_t MifareRead(uint32_t AAddr);
public:
    void Init();
    // Inner use
    void ITask();
    Thread *PThd;
    Spi_t ISpi;
    inline void IrqPinHandler();    // EXTI P70_IRQ Handler
};
#endif

extern PN532_t Pn;

#endif /* PN_H_ */

## Commit log

2015-12-16 + LockNFC3
2018-09-05 Switch to Atollic "Opened" color is blue
2024-02-20 Nothing
